Commit message: added ekf src

File: src/Quadruped-Control-OCS2-ROS2/legged_control/mujoco_simulator/models/quad_mini_tuned/urdf/robot.urdf (robot description, URDF)
Before this commit: robot quad_mini, 19 links, 18 joints
Links:
- link trunk: mass 3.6 -> 4.1
